# Keil uVision project stm32f4discovery-rtt.uvprojx, settings and files
target stm32f4discovery-rtt (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: stm32f4discovery-rtt
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32F407xx
  c include: ..\Drivers; ..\Drivers\CMSIS; ..\Drivers\CMSIS\Device; ..\Drivers\CMSIS\Device\ST; ..\Drivers\CMSIS\Device\ST\STM32F4xx; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Drivers\CMSIS\Include; ..\Drivers\STM32F4xx_HAL_Driver; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Inc; ..\Libraries; ..\Libraries\rt-thread; ..\Libraries\rt-thread\board-407vg; ..\Libraries\rt-thread\components; ..\Libraries\rt-thread\components\drivers; ..\Libraries\rt-thread\components\drivers\include; ..\Libraries\rt-thread\components\drivers\include\drivers; ..\Libraries\rt-thread\HAL_Drivers; ..\Libraries\rt-thread\HAL_Drivers\config; ..\Libraries\rt-thread\HAL_Drivers\config\f4; ..\Libraries\rt-thread\include; ..\Libraries\rt-thread\include\libc; ..\Middlewares; ..\Middlewares\ST; ..\Middlewares\ST\STM32_USB_Device_Library; ..\Middlewares\ST\STM32_USB_Device_Library\Class; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Core; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Middlewares\Third_Party; ..\Middlewares\Third_Party\FatFs; ..\Middlewares\Third_Party\FatFs\src
  asm misc: --cpreproc --cpreproc_opts=-DUSE_HAL_DRIVER,-DSTM32F407xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ..\IDE\MDK5\stm32f4discovery.sct
  group Drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Middlewares
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group RTThread
    ../Libraries/rt-thread/board-407vg/: board.c
    ../Libraries/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ../Libraries/rt-thread/components/drivers/src/: completion.c dataqueue.c
    ../Libraries/rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../Libraries/rt-thread/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
    ../Libraries/rt-thread/components/drivers/misc/: pin.c
    ../Libraries/rt-thread/components/drivers/serial/: serial.c
  group Src-rtt
    ../Src-rtt/: entry.c fatfs.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c user_diskio.c example_uart.c
  group StartUp
    ../IDE/MDK5/: startup_stm32f407xx.s
  group default
    ../Libraries/rt-thread/HAL_Drivers/config/f4/: adc_config.h dma_config.h pwm_config.h qspi_config.h sdio_config.h spi_config.h tim_config.h uart_config.h usbd_fs_config.h
    ../Libraries/rt-thread/board-407vg/: board.h
    ../Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    ../Middlewares/Third_Party/FatFs/src/: diskio.h ff.h ff_gen_drv.h integer.h
    ../Libraries/rt-thread/HAL_Drivers/: drv_common.h drv_config.h drv_dma.h drv_gpio.h drv_log.h drv_usart.h
    ../Libraries/rt-thread/: entry.h rtconfig.h
    ../Inc/: fatfs.h ffconf.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h usb_device.h usbd_cdc_if.h usbd_conf.h usbd_desc.h user_diskio.h
    ../Libraries/rt-thread/include/libc/: libc_dirent.h libc_errno.h libc_fcntl.h libc_fdset.h libc_ioctl.h libc_signal.h libc_stat.h
    ../Libraries/rt-thread/components/drivers/include/drivers/: pin.h serial.h
    ../Libraries/rt-thread/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtlibc.h rtm.h rtservice.h rtthread.h
    ../Libraries/rt-thread/components/drivers/include/: rtdevice.h
    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f407xx.h stm32f4xx.h system_stm32f4xx.h
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_exti.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_ll_usb.h
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
